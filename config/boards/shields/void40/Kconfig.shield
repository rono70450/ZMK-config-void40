## config/boards/shields/void40/Kconfig.shield
```kconfig
config SHIELD_VOID40
    def_bool $(shields_list_contains,void40)
};

&left_encoder {
status = "okay";
};
```
